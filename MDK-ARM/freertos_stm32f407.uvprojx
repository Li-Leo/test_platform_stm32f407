# Keil uVision project freertos_stm32f407.uvprojx, settings and files
target freertos_stm32f407 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: freertos_stm32f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../shell/log;../shell/port;../shell/src;../user/lib;../user;../sfud/inc;../FlashDB/port/fal/inc;../FlashDB/inc
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c i2c.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group shell
    ../shell/port/: shell_port.c log_port.c
    ../shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../shell/log/: log.c
  group user
    ../user/: mid_com.c printf_port.c flash.c drv_key.c key.c rsa.c data_db.c drv_gpio.c drv_rtc_pcf8563.c mid_adc.c thread.c led_tm1652.c
    ../user/lib/: ssz_check.c ssz_common.c ssz_deque.c ssz_list.c ssz_queue.c ssz_safe_queue.c ssz_stack.c ssz_str_utility.c ssz_tick_time.c ssz_time.c ssz_time_utility.c
  group sfud
    ../sfud/port/: sfud_port.c
    ../sfud/src/: sfud.c sfud_sfdp.c
  group flash_db
    ../FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group fal
    ../FlashDB/port/fal/samples/porting/: fal_flash_stm32f4.c fal_flash_sfud_port.c
    ../FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group flash_db_samples
    ../FlashDB/samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
software components: CMSIS:CORE 5.6.0
